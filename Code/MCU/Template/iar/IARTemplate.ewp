# IAR project IARTemplate.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXA153 NXP MCXA153
  ICCARM.CCDefines: CPU_MCXA153VLH; MCXA153_SERIES
  ICCARM.CCIncludePath2: ..\src; ..\inc; ..\device; ..\device\periph; ..\drivers; ..\CMSIS\Include; ..\CMSIS\Include\m-profile
  ICCARM.CCOptLevel: 3
  AARM.ADefines: CPU_MCXA153VLH; MCXA153_SERIES
  AARM.AUserIncludes: ..\src; ..\device; ..\device\periph; ..\drivers; ..\CMSIS\Include
  ILINK.IlinkOutputFile: IARTemplate.out
  ILINK.IlinkIcfFile: MCXA153_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  OBJCOPY.OOCOutputFile: IARTemplate.bin
  group source
    ../src/: led_blinky.c
  group board
    ../src/: board.c clock_config.c pin_mux.c
  group device
    ../device/: system_MCXA153.c
  group startup
    ../device/: startup_MCXA153.s
  group drivers
    ../drivers/: fsl_common.c fsl_common_arm.c fsl_clock.c fsl_reset.c fsl_gpio.c fsl_spc.c
