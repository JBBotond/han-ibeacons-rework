# IAR project Backup of IARTemplate.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXA153VLH NXP MCXA153VLH
  ICCARM.CCDefines: CPU_MCXA153VLH; __STARTUP_CLEAR_BSS
  ICCARM.CCIncludePath2: ..\src; ..\inc; ..\device; ..\device\periph; ..\drivers; ..\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: __STARTUP_CLEAR_BSS
  ILINK.IlinkIcfFile: MCXA153_flash.icf
  ILINK.IlinkOutputFile: IARTemplate.out
  group Application
    ../src/: main.c serial_communication.c serial.c lpuart2.c fifo.c
  group Board
    ../src/: board.c clock_config.c pin_mux.c
  group Device
    ../device/: system_MCXA153.c startup_MCXA153.s
  group Drivers
    ../drivers/: fsl_common.c fsl_common_arm.c fsl_clock.c fsl_reset.c fsl_gpio.c fsl_spc.c
